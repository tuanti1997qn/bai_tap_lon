# Keil uVision project test.uvprojx, settings and files
target baitaplon (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000
  c include: ..\..\blablacaixe;..\Libraries\low_level_drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\low_level_drivers\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\component_drivers\inc;..\Libraries\service_modules\inc;..\Libraries\aplication modules\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c stm32f4xx_it.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../Libraries/low_level_drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group low_level_drivers
    ../Libraries/low_level_drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_usart.c
  group component_drivers
    ../Libraries/component_drivers/src/: i2c.c timer.c PWM.c encoder.c uart.c debug.c gpio.c
  group service_modules
    ../Libraries/service_modules/src/: mpu6050.c kalman_filter.c PID.c
  group aplication modules
    ../Libraries/aplication modules/src/: state_machine.c fuzzy_controller.c
software components: CMSIS:CORE 5.1.1
